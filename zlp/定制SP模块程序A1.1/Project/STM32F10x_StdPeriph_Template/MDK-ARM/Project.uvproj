# Keil uVision project Project.uvproj, settings and files
target STM32f103-EVAL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SP +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\OS\uC-CPU;..\..\..\Libraries\FATFS\src;..\..\..\Libraries\SDIO;..\..\STM32F10x_StdPeriph_Template;..\..\..\Libraries\FATFS\src\option;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\src;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\OS\uCOS-II\Source;..\..\..\OS\uCOS-II;..\..\..\Project\STM32F10x_StdPeriph_Template;..\..\..\OS\uCOS-II\Ports
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../: stm32f10x_it.c main.c target.c PLAYSOUND.c i2s.c malloc.c exfuns.c wavplay.c TEST_WM8978.c bsp_wm8978.c CAN.c task5.c voice.c Playlogic.c
  group uCOS-II
    ../../../OS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-Port
    ../../../OS/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-CPU
    ../../../OS/uC-CPU/: cpu_a.asm
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ./: readme.txt
  group FATFS
    ../../../Libraries/FATFS/src/: diskio.c do_fatfs.c ff.c
    ../../../Libraries/FATFS/src/option/: cc936.c
  group SDIO
    ../../../Libraries/SDIO/: printf.c sdio_sdcard.c
