# Keil uVision project UWB.uvprojx, settings and files
target UWB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L412KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00008000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UWB +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o uwb.bin ./UWB/uwb.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L412xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\DW1000\decadriver;..\DW1000\platform;..\uCOS-II\core;..\uCOS-II\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l412xx.s
  group Application/User
    ../Src/: main.c tag.c anchor.c gpio.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c filtering.c flash.c BEB.c oled.c adc.c usart.c rtc.c key.c crc.c sleep.c
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rng.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group DWM1000_Driver
    ../DW1000/decadriver/: deca_device.c deca_range_tables.c deca_params_init.c
  group DWM1000_PlatForm
    ../DW1000/platform/: port.c deca_mutex.c deca_sleep.c deca_spi.c
  group UCOS-II_CORE
    ../uCOS-II/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-II_PORT
    ../uCOS-II/port/: os_cpu_c.c os_dbg.c os_cpu_a.s
software components: CMSIS:CORE 4.3.0
